Commit message: trajectory

File: urdf/mogi_bot.xacro (robot description, xacro)
@@ -118,3 +118,6 @@
     </visual>
   </link>
+    <gazebo reference="base_link">
+    <material>Gazebo/Green</material>
+  </gazebo>
 </robot>
